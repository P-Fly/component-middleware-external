# Keil uVision project libcunit.uvprojx, settings and files
target libcunit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: libcunit (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\middleware\external\cunit\CUnit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group source
    ../../../../middleware/external/cunit/CUnit/Sources/Basic/: Basic.c
    ../../../../middleware/external/cunit/CUnit/Sources/Console/: Console.c
    ../../../../middleware/external/cunit/CUnit/Sources/Framework/: CUError.c MyMem.c TestDB.c TestRun.c Util.c MessageHandlers.c
